# IAR project dsp_fft.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4=1; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dsp_fft.bin
  ILINK.IlinkOutputFile: dsp_fft.out
  ILINK.IlinkIcfFile: dsp_fft.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Library\CMSIS\Lib\ARM\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../../../../Library/CMSIS/DSP_Lib/Examples/arm_fft_bin_example/: arm_fft_bin_data.c
    ../: main.c
