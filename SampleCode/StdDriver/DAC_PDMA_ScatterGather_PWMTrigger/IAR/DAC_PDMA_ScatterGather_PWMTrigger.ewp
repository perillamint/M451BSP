# IAR project DAC_PDMA_ScatterGather_PWMTrigger.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DAC_PDMA_ScatterGather_PWMTrigger.bin
  ILINK.IlinkOutputFile: DAC_PDMA_ScatterGather_PWMTrigger.out
  ILINK.IlinkIcfFile: DAC_PDMA_ScatterGather_PWMTrigger.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dac.c pdma.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c
