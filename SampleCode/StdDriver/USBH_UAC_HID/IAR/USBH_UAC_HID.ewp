# IAR project USBH_UAC_HID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FATFS\src; ..\..\..\..\Library\UsbHostLib\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_UAC_HID.bin
  ILINK.IlinkOutputFile: USBH_UAC_HID.out
  ILINK.IlinkIcfFile: USBH_UAC_HID.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group USBH Core Library
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH HID Library
    ../../../../Library/UsbHostLib/SOURCE/Hid/: hid_core.c hid_driver.c
  group USBH UAC Library
    ../../../../Library/UsbHostLib/SOURCE/AudioClass/: uac_core.c uac_driver.c uac_parser.c
  group User
    ../: main.c
