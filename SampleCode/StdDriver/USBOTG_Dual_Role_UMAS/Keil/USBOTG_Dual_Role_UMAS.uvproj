# Keil uVision project USBOTG_Dual_Role_UMAS.uvproj, settings and files
target USBOTG_Dual_Role_UMAS (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBOTG_Dual_Role_UMAS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\Include;..\..\..\..\Library\UsbHostLib\Include\inc_mass;..\..\..\..\ThirdParty\FATFS\src
  asm define: Stack_Size=0x1000, Heap_Size=0x100
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c descriptors.c diskio.c MassStorage.c DataFlashProg.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c usbd.c fmc.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_MASS_Lib
    ../../../../Library/UsbHostLib/SOURCE/MassStor/: Umas_FATFS.c UmasDebug.c UmasDriver.c UmasProtocol.c UmasTransport.c
