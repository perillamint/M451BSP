# IAR project freertos_demo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..\; ..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: FreeRTOS_Demo.bin
  ILINK.IlinkOutputFile: FreeRTOS_Demo.out
  ILINK.IlinkIcfFile: FreeRTOS_Demo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group FreeRTOS Files
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/SOURCE/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c
