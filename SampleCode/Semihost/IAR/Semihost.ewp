# IAR project Semihost.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\StdDriver\inc; ..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: Semihost.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../../../Library/StdDriver/src/: clk.c sys.c
    ../: main.c
